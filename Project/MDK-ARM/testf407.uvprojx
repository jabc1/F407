# Keil uVision project testf407.uvprojx, settings and files
target testf407 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: testf407 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\..\Libraries;..\..\Libraries\CORE;..\..\Libraries\FWLIB\inc;..\..\SYSTEM;..\..\USMART;..\..\BSP;..\..\BSP\HardIIC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../Libraries/CORE/: core_cm4.h core_cmSimd.h
    ../../Libraries/StartUp/: startup_stm32f40_41xxx.s
    ../../Libraries/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../../Libraries/FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../../SYSTEM/: delay.c sys.c usart.c
  group USER
    ../../USER/: main.c
  group USMART
    ../../USMART/: usmart.c usmart_config.c usmart_str.c
  group BSP
    ../../BSP/HardIIC/: hardiic.c
    ../../BSP/: bsp_led.c
